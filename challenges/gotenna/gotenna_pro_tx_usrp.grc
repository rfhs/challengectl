options:
  parameters:
    generate_options: no_gui
    id: gotenna_pro_tx_usrp
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: frequency - offset
  states: {}
- name: control_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: data_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '{2400: 400, 4800: 750, 9600: 1100}[baud_rate]'
  states: {}
- name: interp
  id: variable
  parameters:
    value: 480000 // baud_rate
  states: {}
- name: offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: packets
  id: variable
  parameters:
    value: gotenna_packet.encode_pro_broadcast_packets(message_type, counter_num, sender_gid, recipient_gid, callsign, message, publickey_data)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * samp_per_sym * interp
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.gaussian(1.0, samp_per_sym, 0.5, 64)
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud rate
    type: intx
    value: '9600'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pro_synth.cf32
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: 8 * samp_per_sym
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: 8 * samp_per_sym * interp
    type: float
  states: {}
- name: blocks_repeat_2
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.9'
    samp_rate: samp_rate
    sensitivity: 2*math.pi
  states: {}
- name: blocks_vco_c_1
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: baud_rate * samp_per_sym
    sensitivity: 2 * math.pi * fsk_deviation_hz
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: gotenna_packet.pro_gfsk_symbols(packets)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[1]'
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[offset]'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: Sender callsign
    type: str
    value: VE3IRR
  states: {}
- name: counter_num
  id: parameter
  parameters:
    label: Counter
    type: intx
    value: '0'
  states: {}
- name: device_addr
  id: parameter
  parameters:
    label: UHD device address
    type: str
    value: ''
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-3, -1, 3, 1, 0]'
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: '450000000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gotenna_packet
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps
    type: fff
  states: {}
- name: message
  id: parameter
  parameters:
    label: Message
    type: str
    value: Hello world!
  states: {}
- name: message_type
  id: parameter
  parameters:
    label: type
    type: str
    value: BROADCAST
  states: {}
- name: publickey_data
  id: parameter
  parameters:
    label: Sender Public Key
    type: str
    value: base64key
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '25'
    type: ccc
  states: {state: disabled}
- name: recipient_gid
  id: parameter
  parameters:
    label: Recipient GID
    type: intx
    value: '1234567891'
  states: {}
- name: sender_gid
  id: parameter
  parameters:
    label: Sender GID
    type: intx
    value: '1234567890'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_addr: device_addr
    dev_args: '""'
    gain0: '70'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_repeat_2, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_xx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_repeat_1, '0', blocks_vco_c_0, '0']
- [blocks_repeat_2, '0', interp_fir_filter_xxx_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_1, '1']
- [blocks_vco_c_1, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', digital_map_bb_0, '0']
- [blocks_vector_source_x_1, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_2, '0', blocks_repeat_1, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_vco_c_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
