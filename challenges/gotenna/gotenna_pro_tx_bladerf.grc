options:
  parameters:
    generate_options: no_gui
    id: gotenna_pro_tx_bladerf
    output_language: python
    run_options: run
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: frequency - offset
  states: {}
- name: control_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: data_chan
  id: variable
  parameters:
    value: '2'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '{2400: 400, 4800: 750, 9600: 1100}[baud_rate]'
  states: {}
- name: hw_rate
  id: variable
  parameters:
    value: '5760000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: 480000 // baud_rate
  states: {}
- name: offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: packets
  id: variable
  parameters:
    value: gotenna_packet.encode_pro_broadcast_packets(message_type, counter_num, sender_gid, recipient_gid, callsign, message, publickey_data)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * samp_per_sym * interp
  states: {}
- name: silence_time
  id: variable
  parameters:
    value: '4000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.gaussian(1.0, samp_per_sym, 0.5, 64)
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: Transmit antenna
    type: str
    value: ''
  states: {}
- name: baud_rate
  id: parameter
  parameters:
    label: Baud rate
    type: intx
    value: '9600'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: 8 * samp_per_sym
    type: complex
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: 8 * samp_per_sym * (hw_rate // (baud_rate * samp_per_sym))
    type: float
  states: {}
- name: blocks_repeat_2
  id: blocks_repeat
  parameters:
    interp: samp_per_sym
    type: float
  states: {}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '0.9'
    samp_rate: hw_rate
    sensitivity: 2*math.pi
  states: {}
- name: blocks_vco_c_1
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: baud_rate * samp_per_sym
    sensitivity: 2 * math.pi * fsk_deviation_hz
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: '[0]*silence_time+gotenna_packet.pro_gfsk_symbols(packets)+[0]*silence_time'
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[1]'
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[offset]'
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: Sender callsign
    type: str
    value: VE3IRR
  states: {}
- name: counter_num
  id: parameter
  parameters:
    label: Counter
    type: intx
    value: '0'
  states: {}
- name: device_args
  id: parameter
  parameters:
    label: Osmocom device arguments
    type: str
    value: bladerf=0,biastee=1
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-3, -1, 3, 1, 0]'
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Frequency
    type: eng_float
    value: '450000000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gotenna_packet
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps
    type: fff
  states: {}
- name: message
  id: parameter
  parameters:
    label: Message
    type: str
    value: Hello world!
  states: {}
- name: message_type
  id: parameter
  parameters:
    label: type
    type: str
    value: BROADCAST
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    ant0: antenna
    args: device_args
    bb_gain0: '0'
    bw0: '1000000'
    freq0: center_freq
    gain0: '60'
    if_gain0: '0'
    sample_rate: hw_rate
    sync: sync
    type: fc32
  states: {}
- name: publickey_data
  id: parameter
  parameters:
    label: Sender Public Key
    type: str
    value: base64key
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: hw_rate // (baud_rate * samp_per_sym)
    taps: ''
    type: ccc
  states: {}
- name: recipient_gid
  id: parameter
  parameters:
    label: Recipient GID
    type: intx
    value: '1234567891'
  states: {}
- name: sender_gid
  id: parameter
  parameters:
    label: Sender GID
    type: intx
    value: '1234567890'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_repeat_2, '0']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_1, '0', osmosdr_sink_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '1']
- [blocks_repeat_1, '0', blocks_vco_c_0, '0']
- [blocks_repeat_2, '0', interp_fir_filter_xxx_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_1, '1']
- [blocks_vco_c_1, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', digital_map_bb_0, '0']
- [blocks_vector_source_x_1, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_2, '0', blocks_repeat_1, '0']
- [digital_map_bb_0, '0', blocks_char_to_float_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_vco_c_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
